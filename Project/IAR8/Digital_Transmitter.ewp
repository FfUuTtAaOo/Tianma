# IAR project Digital_Transmitter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LH32M0G3x LegendSemi LH32M0G3x
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Drivers\LHL\LH32M0G3x\inc; ..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\Device\LH32M0G3x
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.srec
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lhl
    ../../../../Drivers/LHL/LH32M0G3x/lib/: lh32m0g3x_adc.c lh32m0g3x_btim.c lh32m0g3x_crc.c lh32m0g3x_dac.c lh32m0g3x_dma.c lh32m0g3x_dmamux.c lh32m0g3x_eeprom.c lh32m0g3x_exti.c lh32m0g3x_flash.c lh32m0g3x_gpio.c lh32m0g3x_i2c.c lh32m0g3x_iwdg.c lh32m0g3x_lhl.c lh32m0g3x_lptim.c lh32m0g3x_mcal.c lh32m0g3x_mio.c lh32m0g3x_power.c lh32m0g3x_rcc.c lh32m0g3x_rtc.c lh32m0g3x_spi.c lh32m0g3x_timer.c lh32m0g3x_uart.c lh32m0g3x_xlink.c
  group startup
    ../../../../Device/LH32M0G3x/IAR/: startup_lh32m0g3x.s
    ../../../../Device/LH32M0G3x/: system_lh32m0g3x.c
  group user
    ../: lh32m0xx_it.c main.c
